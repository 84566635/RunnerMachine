# Keil uVision project RFID_V1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: RFID_V1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group SRC
    ./: E2PROM.c main.c RC522.c uart.c
  group INC
    ./: E2PROM.h main.h MFRC522.h uart.h
  group Document
    ./: 版本说明.txt
